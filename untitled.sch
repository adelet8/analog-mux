v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/vsource.sym} 590 -280 0 0 {name=V1 value=3}
C {devices/vsource.sym} 730 -270 0 0 {name=V2 value=3}
